
SUMMARY = "This package intends to offer a method of parsing crontab schedule entries and determining when an item should next be run"
HOMEPAGE = "None"
LICENSE = "LGPL-2.1-or-later"
LIC_FILES_CHKSUM = "file://LICENSE;md5=23c2a5e0106b99d75238986559bb5fc6"

SRC_URI[md5sum] = "77ddc1000a05cbcf82e4471d6382cbef"
SRC_URI[sha256sum] = "f80e01b4f07219763a9869f926dd17147278e7965a928089bca6d3dc80ae46d5"




inherit pypi setuptools3

